# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,ARM_MATH_CM3
  c include: .\Hardware;.\Library;.\Start;.\System;.\User;.\DSPlib\Include;.\Hardware;.\LCD;.\HMI
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Hardware
    ./Hardware/: Led.c Led.h Key.c Key.h OLED.c OLED.h OLED_Font.h Key_EXTI.c Key_EXTI.h Beep.c Beep.h Timer.c Timer.h PWM.c PWM.h Serial.c Serial.h SerialPackRT.c SerialPackRT.h Timing Sampling.c Timing Sampling.h AD9959.C AD9959.h AD9959_Outset.c AD9959_Outset.h matrix_keypad.c matrix_keypad.h AD9833.c AD9833.h
  group Library
    ./Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group Start
    ./Start/: core_cm3.c startup_stm32f10x_hd.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group System
    ./System/: Delay.c Delay.h cr4_fft_256_stm32.s cr4_fft_1024_stm32.s stm32_dsp.h table_fft.h sys.c sys.h
  group User
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.h stm32f10x_it.c main.h RLCtest.c RLCtest.h check_err.c check_err.h
  group LCD
    ./LCD/: lcd.c lcd.h lcdfont.h
  group HMI
    ./HMI/: tjc_usart_hmi.c tjc_usart_hmi.h
software components: CMSIS:CORE 5.4.0, CMSIS:DSP 1.8.0
